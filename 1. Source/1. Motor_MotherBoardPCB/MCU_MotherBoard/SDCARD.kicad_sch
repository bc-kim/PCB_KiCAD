File: 1. Source/1. Motor_MotherBoardPCB/MCU_MotherBoard/SDCARD.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: !
Parts:
- gave numbers to parts that had none: 1

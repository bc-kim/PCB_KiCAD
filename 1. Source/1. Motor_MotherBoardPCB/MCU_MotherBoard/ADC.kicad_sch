File: 1. Source/1. Motor_MotherBoardPCB/MCU_MotherBoard/ADC.kicad_sch (KiCad schematic)
At the start: 29 parts

Commit message: !
Parts:
- gave numbers to parts that had none: 29
